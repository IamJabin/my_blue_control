# Keil uVision project LedBlink.uvprojx, settings and files
target N32WB452 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LedBlink +hex
  AfterMake: fromelf --bin --output=.\bin\LedBlink.bin .\Objects\LedBlink.axf
  c flags: Optim=2 v6Lang=1 v6LangP=5 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32wb452_std_periph_driver\inc;..\firmware\n32wb452_std_periph_driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../firmware/n32wb452_std_periph_driver/src/: n32wb452_gpio.c n32wb452_rcc.c
  group USER
    ../src/: main.c n32wb452_it.c
  group DOC
    ../: readme.txt
